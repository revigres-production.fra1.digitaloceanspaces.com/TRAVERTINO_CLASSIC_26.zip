Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 8eab63fa-3269-4b29-80fa-01a2dedfe2c5, NumberOfSaves: 202], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T17:18:19+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-OFFWHITE, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-OFFWHITE:151090
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x118,6-MATTRECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X380V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x118.6 -RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-SAND, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-SAND:151098
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x118,6-MATTRECT-SAND
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X381V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x118.6 -RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-OFFWHITE, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-OFFWHITE:151106
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x277,8-MATTRECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X480V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 900 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x277.8-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-SAND, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-SAND:151114
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x277,8-MATTRECT-SAND
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X481V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 900 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x277.8-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-OFFWHITE, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-OFFWHITE:151033
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x118,6-MATTRECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 31211380V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x118.6-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-SAND, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-SAND:151075
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x59,2-MATTRECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121D381V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x118.6-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATT RECT-SAND, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATT RECT-SAND:151059
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x59,2-MATTRECT-SAND
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 31211380V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x59.2-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATTRECT-OFFWHITE, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATTRECT-OFFWHITE:151015
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x59,2-MATTRECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 31211381V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x59.2-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-88.9x88.9-MATT RECT-OFFWHITE, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-88.9x88.9-MATT RECT-OFFWHITE:151024
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-88,9,2x88,9-MATTRECT-OFFWHITE
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121K780V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 90 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-88.9x88x9-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-88.9x88.9-MATT RECT-SAND, Basic Wall:REVIGRES-TRAVERTINO CLASSIC-BASE-88.9x88.9-MATT RECT-SAND:151067
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3020 Uniformat (Uniformat); Material: REVIGRES-TRAVERTINO CLASSIC-BASE-88,9,2x88,9-MATTRECT-SAND
IFC.REVIGRES-Dados do fabricante-Wall Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121K781V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Wall Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Wall Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Wall Covering - AlturaNominal: 10.5 mm; ComprimentoNominal: 90 mm; LarguraNominal: 90 mm
IFC.REVIGRES-Dados de sustentabilidade-Wall Covering - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739
IFC.REVIGRES-Dados gerais-Wall Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-88.9x88x9-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-OFFWHITE, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-OFFWHITE:151093
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x118,6-MATTRECT-OFFWHITE
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X380V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x118.6 -RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-SAND, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x118.6-MATT RECT-SAND:151101
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x118,6-MATTRECT-SAND
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X381V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 3500 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9 mm; ComprimentoNominal: 120 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x118.6 -RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-OFFWHITE, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-OFFWHITE:151109
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x277,8-MATTRECT-OFFWHITE
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X480V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 900 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x277.8-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-SAND, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-118.6x277.8-MATT RECT-SAND:151117
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-118,6x277,8-MATTRECT-SAND
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121X481V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAFlexao: > 900 N; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 6 mm; ComprimentoNominal: 120 mm; LarguraNominal: 278 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-118.6x277.8-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-OFFWHITE, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-OFFWHITE:151036
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x118,6-MATTRECT-OFFWHITE
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 31211380V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x118.6-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-SAND, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x118.6-MATT RECT-SAND:151078
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x118,6-MATTRECT-SAND
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 3121D381V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 120 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x118.6-RECT-SAND; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATT RECT-SAND, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATT RECT-SAND:151062
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x59,2-MATTRECT-SAND
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 31211380V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Floor Covering - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ResistenciaAoEscorregamentoDIN51130: R10; ResistenciaAoEscorregamentoDIN51097: B; ResistenciaAoEscorregamentoENV51097: B; ResistenciaAoEscorregamentoENV12633: Class 2; ResistenciaAoEscorregamentoBS7976: 36+; ResistenciaAoEscorregamentoANSIA1371: ≥0,42; ResistenciaAoDeslizamentoENV12633: Class 2; ResistenciaAoDeslizamentoBS7976: 36+; ResistenciaAsManchas: Class 5; ResistenciaABaixasConcentracoesDeAcidosEAlcalis: Classe LA; ResistenciaAAltasConcentracoesDeAcidosEAlcalis: Classe HA; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Floor Covering - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Sim; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Floor Covering - AlturaNominal: 9.8 mm; ComprimentoNominal: 60 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Floor Covering - EnergiaTermicaExportada: 0; ItemENovo: Sim; ItemEParcialmenteReciclado: 0.075; ItemEReciclado: Sim; VidaÚtilEsperada: 50; SubstanciasPerigosas: Não; PotencialDeEsgotamentoAbioticoDosRecursosFosseis: 203; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²
IFC.REVIGRES-Dados gerais-Floor Covering - Nome: REVIGRES-TRAVERTINO_CLASSIC-BASE-59.2x59.2-RECT-OFFWHITE; TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -

# IfcCovering: Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATTRECT-OFFWHITE, Floor:REVIGRES-TRAVERTINO CLASSIC-BASE-59.2x59.2-MATTRECT-OFFWHITE:151018
In: Level 1
Type - PredefinedType: CLADDING; Material: REVIGRES-TRAVERTINO CLASSIC-BASE-59,2x59,2-MATTRECT-OFFWHITE
Type - Pset_CoveringCommon - Reference: 3121135V21; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 3121135V21
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Classification: C3010 Uniformat (Uniformat)
IFC.REVIGRES-Dados do fabricante-Floor Covering - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; NumeroGlobalDeItemComercial: 31211381V1; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/travertino-classic; PaisOrigem: Portugal
