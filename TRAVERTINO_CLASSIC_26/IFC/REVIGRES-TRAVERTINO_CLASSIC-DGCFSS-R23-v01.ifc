Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 54f6b6af-cd8a-4e44-9323-5d201a1035fa, NumberOfSaves: 5], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site], ExchangeRequirement [Architecture]
Time: 2026-06-12T17:19:06+00:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.40.56 (ENU) - IFC 23.3.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: REVIGRES-TRAVERTINO_CLASSIC-DGCFSS-R23-v01:29.5x59.2-RECT-OFFWHITE, REVIGRES-TRAVERTINO_CLASSIC-DGCFSS-R23-v01:29.5x59.2-RECT-OFFWHITE:17393
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-TRAVERTINO CLASSIC-DGCF-29,5X59,2-MATTRECT-OFFWHITE
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-TRAVERTINO CLASSIC-DGCF-29,5X59,2-MATTRECT-OFFWHITE
Pset_CoveringCommon - Reference: 29.5x59.2-RECT-OFFWHITE
Pset_EnvironmentalImpactIndicators - Reference: 29.5x59.2-RECT-OFFWHITE
IFC.REVIGRES-Dados gerais-Generic Model - TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - PesoLiquido: 0; FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/silver-roots; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - ClassificacaoFogo: 0 mm; Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 3 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaTermicaExportada: 0; PotencialDeAquecimentoGlobalTotal: 0; ItemEParcialmenteReciclado: 0.075; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; EnergiaElectricaExportada: 1.55; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²

# IfcCovering: REVIGRES-TRAVERTINO_CLASSIC-DGCFSS-R23-v01:29.5x59.2-RECT-SAND, REVIGRES-TRAVERTINO_CLASSIC-DGCFSS-R23-v01:29.5x59.2-RECT-SAND:17378
In: Level 1
Type - PredefinedType: FLOORING
Type - Pset_CoveringCommon - IsExternal: no; Finish: REVIGRES-TRAVERTINO CLASSIC-DGCF-29,5X59,2-MATTRECT-SAND
Type - Pset_ManufacturerTypeInformation - Manufacturer: REVIGRES
Material: REVIGRES-TRAVERTINO CLASSIC-DGCF-29,5X59,2-MATTRECT-SAND
Pset_CoveringCommon - Reference: 29.5x59.2-RECT-SAND
Pset_EnvironmentalImpactIndicators - Reference: 29.5x59.2-RECT-SAND
IFC.REVIGRES-Dados gerais-Generic Model - TipoProduto: Prensado a seco: grupo BIa UGL | Grés porcelânico técnico; NumeroDeRegistoDAP: EPD-REV-20240006-CCC1-EN; ReferenciaDAP: -; UrlDOP: -
IFC.REVIGRES-Dados do fabricante-Generic Model - FabricanteURL: https://www.revigres.pt/; ReferenciaModelo: Travertino Classic; PesoLiquido: 0; Acabamento: RECT; Material: Grés porcelânico; IdentificadorDoOperadorEconomico: 501840856; UrlFabricanteArtigo: https://www.revigres.pt/colecoes/silver-roots; PaisOrigem: Portugal
IFC.REVIGRES-Dados de desempenho-Generic Model - Rectilinearidade: ± 0.3% máx. ± 1.5 mm; Ortogonalidade: ± 0.3% máx. ± 1.8 mm; PlanaridadeDaSuperficie: ± 0.3% máx. ± 1.8 mm; QualidadeDaSuperficie: Cumpre; AbsorcaoDeAgua: < 0.05%; ModuloDeRuptura: > 45 N/mm²; ResistenciaAAbrasaoProfunda: < 120 mm³; DilatacaoTermicaLinear: ≤ 8,0x10-6 °C-1; ResistenciaAoChoqueTermico: Resiste; DurabilidadeInterior: Cumpre; DurabilidadeResistenciaAoGeloDegelo: Resiste; ClassificacaoFogo: 0 mm; LibertacaoDeCadmio: 0; LibertacaoDeChumbo: 0
IFC.REVIGRES-Dados de especificação-Generic Model - VariacaoTonalidade: 3; NivelDeTrafego: 3; EPavimento: Sim; ERevestimento: Não; EExterno: Sim
IFC.REVIGRES-Dados geométricos-Generic Model - AlturaNominal: 3 mm; ComprimentoNominal: 30 mm; LarguraNominal: 60 mm
IFC.REVIGRES-Dados de sustentabilidade-Generic Model - ItemEParcialmenteReciclado: 0.075; PotencialDeEsgotamentoAbioticoDosRecursosNaoFosseisMineraisEMetais: 0.000701; PotencialDeAquecimentoGlobalBiogenico: -0.48; CombustiveisFosseisComPotencialDeAquecimentoGlobal: 13.9; PotencialDeAquecimentoGlobalUsoDoSoloEMudancaDeUsoDoSolo: 0.0246; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalDeAguaDoce: 0.000189; PotencialDeEutrofizacaoFraccaoDeNutrientesQueAtingemOCompartimentoFinalMarinho: 0.0122; PotencialPrivacaoDeAguaConsumoDeAguaPonderado: 4.5; EnergiaRecuperada: 0.00739; ConsumoDeAguaDoce: 0.113; UtilizacaoLiquidaDeAguaDoce: 0.113; ResiduosPerigososEliminados: 0.00221; ResiduosNaoPerigososEliminados: 1.83; MassaTotalDeResiduosRadioactivosEliminados: 0.000394; VolumeTotalDeResiduosRadioactivosEliminados: 0; EnergiaElectricaExportada: 1.55; EnergiaTermicaExportada: 0; MateriaisParaRecuperacaoDeEnergia: 0.00739; MateriaisParaReciclagem: 0.0253; UnidadeEPD: 1 m²; PotencialDeAquecimentoGlobalTotal: 0
